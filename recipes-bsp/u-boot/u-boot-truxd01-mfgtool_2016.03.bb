require u-boot-truxd01_${PV}.bb
require recipes-bsp/u-boot/u-boot-mfgtool.inc
