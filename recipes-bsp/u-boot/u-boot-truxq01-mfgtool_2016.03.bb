require u-boot-truxq01_${PV}.bb
require recipes-bsp/u-boot/u-boot-mfgtool.inc
